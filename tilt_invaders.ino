/*
  Tilt Invaders - 3D space invaders for the Waveshare ESP32-S3-LCD-1.28 (GC9A01 round LCD + QMI8658 IMU)

  The screen is a window onto an un-named desert planet:
    - held LEVEL (flat) you look straight down at the sand
    - raise the top edge: the horizon appears at the top of the screen and lowers, the sky and the invaders come into view
    - tilt left / right to turn (up to 60 degrees each way); you can look up to 60 degrees above the horizon
    - BOOT fires the laser straight ahead (where the crosshair is). Two hits destroy an invader.
  The invaders shift left, shift right, then come a little closer to the ground; if one lands it is game over.
  They shoot straight at you: a bolt grows where the invader was, and it only hits if your crosshair is on
  that spot when it arrives. Every hit costs a bonus (you start with 3); clearing a level gives one back (max 10).
  Level 1 has one invader, level 2 has two, and so on: there is no end.

  BOOT button: fire (in the game) / start again (after game over). Hold it ~1.5 s to recalibrate "level".

  Files in this sketch folder:
    tilt_invaders.ino   this file (hardware, tilt input, main loop)
    inv_game.h          the game rules and the invaders' behaviour
    inv_render.h        the 3D drawing
    inv_sprites.h       the pixel art

  Library needed: "GFX Library for Arduino" (moononournation)
  Board: ESP32S3 Dev Module, USB CDC On Boot = Disabled, Flash 16MB, PSRAM optional.
*/

#include <Arduino_GFX_Library.h>
#include <Wire.h>
#include "esp_heap_caps.h"

#include "inv_render.h"

// Newer Arduino_GFX versions removed the short colour names, so define the ones we use
#ifndef BLACK
#define BLACK  0x0000
#define WHITE  0xFFFF
#define RED    0xF800
#endif

// ---------------- Pins (non-touch ESP32-S3-LCD-1.28) ----------------
#define PIN_SCK   10
#define PIN_MOSI  11
#define PIN_CS     9
#define PIN_DC     8
#define PIN_RST   12
#define PIN_BL    40
#define PIN_SDA    6
#define PIN_SCL    7
#define PIN_BOOT   0

// ---------------- How the tilt steers the view ----------------
// Pitch: flat = looking straight down (-90 deg). Every degree you raise the top edge lifts the view by PITCH_GAIN
// degrees, so you do not need to tilt the board past upright to look 60 degrees above the horizon.
// Yaw: tilting the board left/right turns the view by YAW_GAIN degrees per degree of tilt.
const float PITCH_GAIN  = 1.5f;
const float YAW_GAIN    = 4.0f;
const float PITCH_MIN   = -90.0f;     // straight down
const float PITCH_MAX   = 60.0f;      // 60 degrees above the horizon
const float YAW_MAX     = 60.0f;      // 60 degrees left and right
#define INVERT_PITCH 0                // set to 1 if raising the top edge lowers the view
#define INVERT_YAW   1                // set to 1 if tilting right turns the view left
const float VIEW_TAU    = 0.5f;      // seconds of smoothing on the view
#define DEBUG_SERIAL 1

// ---------------- Display ----------------
Arduino_DataBus *bus = new Arduino_ESP32SPI(PIN_DC, PIN_CS, PIN_SCK, PIN_MOSI, GFX_NOT_DEFINED);
Arduino_GFX *gfx = new Arduino_GC9A01(bus, PIN_RST, 0 /*rotation*/, true /*IPS*/);

// ---------------- Boot-screen logo (webwarrior.org, 86x13 pixel art, RGB565), drawn unscaled ----------------
#define LOGO_W 86
#define LOGO_H 13
const uint16_t logo_ww[LOGO_W * LOGO_H] PROGMEM = {
0x5B4B,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,
0x636C,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0x636C,
0x636C,0xFFFF,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0xFFFF,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xFFFF,0x636C,
0x636C,0xFFFF,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0xFFFF,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xFFFF,0x636C,
0x636C,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0x8C6F,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0x8C6F,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0x8C6F,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0x8C6F,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0x8C6F,0xFFFF,0xF800,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xF800,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xF800,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xF800,0xFFFF,0x636C,
0x636C,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0xF800,0xFFFF,0xF800,0xF800,0xF800,0xFFFF,0xF800,0xFFFF,0xF800,0xF800,0xF800,0xFFFF,0xF800,0xFFFF,0xF800,0xF800,0xF800,0xF800,0xF800,0xFFFF,0x636C,
0x636C,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0x8C6F,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0xF800,0xFFFF,0xF800,0xF800,0xF800,0xFFFF,0xF800,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xF800,0xF800,0xFFFF,0xF800,0xFFFF,0xFFFF,0xFFFF,0xF800,0xFFFF,0x636C,
0x636C,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0xF800,0xFFFF,0xF800,0xF800,0xF800,0xFFFF,0xF800,0xFFFF,0xF800,0xF800,0xF800,0xFFFF,0xF800,0xFFFF,0xF800,0xF800,0xF800,0xFFFF,0xF800,0xFFFF,0x636C,
0x636C,0xFFFF,0x8C6F,0x8C6F,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0x8C6F,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0x8C6F,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0x8C6F,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0x8C6F,0xFFFF,0x8C6F,0x8C6F,0x8C6F,0xFFFF,0x8C6F,0xFFFF,0xF800,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xF800,0xFFFF,0xF800,0xF800,0xF800,0xFFFF,0xF800,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xF800,0xFFFF,0x636C,
0x636C,0xFFFF,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0xFFFF,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xFFFF,0x636C,
0x636C,0xFFFF,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0x8C6F,0xFFFF,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xF800,0xFFFF,0x636C,
0x636C,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0xFFFF,0x636C,
0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C,0x636C
};

// Draws the logo at its native size, centred horizontally on cx with its top edge at y.
void drawLogo(int cx, int y) {
  int x0 = cx - LOGO_W / 2;
  for (int j = 0; j < LOGO_H; j++) {
    int i = 0;
    while (i < LOGO_W) {
      uint16_t c = logo_ww[j * LOGO_W + i];
      int k = i + 1;
      while (k < LOGO_W && logo_ww[j * LOGO_W + k] == c) k++;
      gfx->fillRect(x0 + i, y + j, k - i, 1, c);
      i = k;
    }
  }
}


// ---------------- IMU (QMI8658) ----------------
#define QMI_WHO_AM_I 0x00
#define QMI_CTRL1    0x02
#define QMI_CTRL2    0x03
#define QMI_CTRL7    0x08
#define QMI_AX_L     0x35
#define QMI_RESET    0x60

uint8_t imuAddr = 0;
float zSign = 1.0f;          // which way the sensor's z axis points when the board lies flat, screen up
float alpha0 = 0, beta0 = 0; // calibrated "level"

bool i2cWrite(uint8_t reg, uint8_t val) {
  Wire.beginTransmission(imuAddr);
  Wire.write(reg);
  Wire.write(val);
  return Wire.endTransmission() == 0;
}

bool i2cRead(uint8_t reg, uint8_t *buf, int n) {
  Wire.beginTransmission(imuAddr);
  Wire.write(reg);
  if (Wire.endTransmission(false) != 0) return false;
  if (Wire.requestFrom((int)imuAddr, (int)n) != n) return false;
  for (int i = 0; i < n; i++) buf[i] = Wire.read();
  return true;
}

bool imuInit() {
  Wire.begin(PIN_SDA, PIN_SCL);
  Wire.setClock(400000);
  const uint8_t addrs[2] = {0x6B, 0x6A};
  bool found = false;
  for (int i = 0; i < 2 && !found; i++) {
    imuAddr = addrs[i];
    uint8_t id = 0;
    if (i2cRead(QMI_WHO_AM_I, &id, 1) && id == 0x05) found = true;
  }
  if (!found) return false;
  i2cWrite(QMI_RESET, 0xB0);   // soft reset
  delay(30);
  i2cWrite(QMI_CTRL1, 0x40);   // address auto-increment
  i2cWrite(QMI_CTRL2, 0x05);   // accel +-2g, 250 Hz
  i2cWrite(QMI_CTRL7, 0x01);   // enable accelerometer
  delay(20);
  return true;
}

bool readAccel(float &ax, float &ay, float &az) {
  uint8_t b[6];
  if (!i2cRead(QMI_AX_L, b, 6)) return false;
  int16_t rx = (int16_t)(b[0] | (b[1] << 8));
  int16_t ry = (int16_t)(b[2] | (b[3] << 8));
  int16_t rz = (int16_t)(b[4] | (b[5] << 8));
  ax = rx / 16384.0f;
  ay = ry / 16384.0f;
  az = rz / 16384.0f;
  return true;
}

// Board attitude from gravity. alpha: how far the top edge is raised (0 = flat, 90 = upright), beta: how far the
// right edge is lowered. Returns false if the board is in free fall / being shaken too hard to tell.
bool attitude(float ax, float ay, float az, float &alpha, float &beta) {
  float ux = ax, uy = ay, uz = az * zSign;
  float n = sqrtf(ux * ux + uy * uy + uz * uz);
  if (n < 0.5f || n > 1.8f) return false;
  ux /= n; uy /= n; uz /= n;
  alpha = atan2f(-uy, uz);
  if (alpha < -2.2f) alpha += 6.2831853f;                // past face-down: keep going instead of wrapping
  beta = atan2f(-ux, sqrtf(uy * uy + uz * uz));
  return true;
}

// ---------------- Boot screen helpers ----------------
void centerText(const char *txt, int y, int size, uint16_t color) {
  int w = strlen(txt) * 6 * size;
  gfx->setTextSize(size);
  gfx->setTextColor(color);
  gfx->setCursor(120 - w / 2, y);
  gfx->print(txt);
}

// the classic crab invader, green on black, at 3x
void drawBootInvader(int cx, int y) {
  const int S = 3, W = 11;
  const uint16_t green = 0x3FEE;
  int x0 = cx - (W * S) / 2;
  for (int r = 0; r < 8; r++) {
    uint16_t bits = INV_CRAB0[r];
    int c = 0;
    while (c < W) {
      if (!((bits >> (W - 1 - c)) & 1)) { c++; continue; }
      int k = c;
      while (k < W && ((bits >> (W - 1 - k)) & 1)) k++;
      gfx->fillRect(x0 + c * S, y + r * S, (k - c) * S, S, green);
      c = k;
    }
  }
}

void calibrateLevel() {
  gfx->fillScreen(BLACK);
  drawBootInvader(120, 76);                // the typical invader ...
  drawLogo(120, 114);                      // ... the usual logo, at its native size ...
  centerText("Hold level", 138, 2, WHITE); // ... and the instruction
  delay(1500);
  float sx = 0, sy = 0, sz = 0;
  int n = 0;
  for (int i = 0; i < 60; i++) {
    float x, y, z;
    if (readAccel(x, y, z)) { sx += x; sy += y; sz += z; n++; }
    delay(10);
  }
  if (n) {
    sx /= n; sy /= n; sz /= n;
    zSign = sz >= 0 ? 1.0f : -1.0f;       // flat and screen up: this makes "up" read as +z
    float a, b;
    if (attitude(sx, sy, sz, a, b)) { alpha0 = a; beta0 = b; }
  }
}

// ---------------- Game state ----------------
uint16_t *fb = nullptr;
float viewYaw = 0, viewPitch = -1.5707963f;     // smoothed camera angles (radians)
uint32_t lastUs = 0, fpsMs = 0, pressStart = 0, overMs = 0;
int frames = 0;
bool btnWasDown = false, recalDone = false;

void setup() {
  Serial.begin(115200);
  pinMode(PIN_BL, OUTPUT);
  digitalWrite(PIN_BL, HIGH);
  pinMode(PIN_BOOT, INPUT_PULLUP);

  if (!gfx->begin()) {
    Serial.println("Display init failed");
    while (true) delay(1000);
  }
  gfx->fillScreen(BLACK);

  if (!imuInit()) {
    centerText("IMU not found", 110, 2, RED);
    Serial.println("QMI8658 not found");
    while (true) delay(1000);
  }

  fb = (uint16_t *)heap_caps_malloc(IW * IW * 2, MALLOC_CAP_INTERNAL | MALLOC_CAP_8BIT);
  if (!fb) fb = (uint16_t *)heap_caps_malloc(IW * IW * 2, MALLOC_CAP_SPIRAM | MALLOC_CAP_8BIT);
  if (!fb) {
    centerText("Out of memory", 110, 2, RED);
    while (true) delay(1000);
  }
  memset(fb, 0, IW * IW * 2);

  uint32_t seed = esp_random();
  inv_render_init(seed);
  calibrateLevel();
  inv_new_game(seed ^ 0x9E3779B9u);
  lastUs = micros();
}

void loop() {
  // --- BOOT button: fire / start again; hold to recalibrate ---
  bool down = (digitalRead(PIN_BOOT) == LOW);
  if (down && !btnWasDown) {
    pressStart = millis();
    if (inv_state == INV_OVER) { if (millis() - overMs > 700) inv_new_game(esp_random()); }
    else inv_fire();
  }
  if (down && !recalDone && millis() - pressStart > 1500) {
    recalDone = true;
    calibrateLevel();
    lastUs = micros();
  }
  if (!down) recalDone = false;
  btnWasDown = down;

  // --- time ---
  uint32_t now = micros();
  float dt = (now - lastUs) / 1e6f;
  lastUs = now;
  if (dt > 0.1f) dt = 0.1f;

  // --- tilt -> where the camera looks ---
  float ax, ay, az, alpha, beta;
  if (readAccel(ax, ay, az) && attitude(ax, ay, az, alpha, beta)) {
    float pitchDeg = PITCH_MIN + PITCH_GAIN * (alpha - alpha0) * 57.29578f;
    float yawDeg = YAW_GAIN * (beta - beta0) * 57.29578f;
#if INVERT_PITCH
    pitchDeg = PITCH_MIN - (pitchDeg - PITCH_MIN);
#endif
#if INVERT_YAW
    yawDeg = -yawDeg;
#endif
    if (pitchDeg < PITCH_MIN) pitchDeg = PITCH_MIN;
    if (pitchDeg > PITCH_MAX) pitchDeg = PITCH_MAX;
    if (yawDeg < -YAW_MAX) yawDeg = -YAW_MAX;
    if (yawDeg > YAW_MAX) yawDeg = YAW_MAX;
    float k = 1.0f - expf(-dt / VIEW_TAU);
    viewPitch += (pitchDeg * 0.0174533f - viewPitch) * k;
    viewYaw += (yawDeg * 0.0174533f - viewYaw) * k;
  }

  // --- game ---
  int prevState = inv_state;
  inv_update(dt, viewYaw, viewPitch);
  if (inv_state == INV_OVER && prevState != INV_OVER) overMs = millis();

  // --- draw ---
  inv_render(fb, viewYaw, viewPitch);
  gfx->draw16bitRGBBitmap(0, 0, fb, IW, IW);

#if DEBUG_SERIAL
  if (inv_state != prevState) Serial.printf("state %d, level %d, bonuses %d\n", inv_state, inv_level, inv_bonus);
  frames++;
  if (millis() - fpsMs >= 2000) {
    Serial.printf("%.1f fps  pitch %.0f yaw %.0f  level %d  bonuses %d\n", frames * 1000.0f / (millis() - fpsMs), viewPitch * 57.29578f, viewYaw * 57.29578f, inv_level, inv_bonus);
    frames = 0;
    fpsMs = millis();
  }
#endif
}